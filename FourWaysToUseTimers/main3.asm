		ORG 0000H
		LJMP MAIN
		ORG 000BH
		LJMP T0_F
		ORG 001BH
		LJMP T1_F
		ORG 0023H
		LJMP USART
MAIN:	MOV TL0,#0
		MOV TH0,#230
		MOV TL1,#230
		MOV TH1,#250
		MOV TMOD,#23H
		MOV A,#80H
		ORL A,PCON
		MOV PCON,A
		SETB SM1
		SETB REN
		SETB ET0
		SETB ET1
		SETB ES
		SETB EA
		SETB TR0
		SETB TR1
HERE:	SJMP HERE
T0_F:	CPL P1.0
		MOV TL0,#230
		RETI
T1_F:	CPL P1.1
		MOV TH0,#230
		RETI
USART:	JBC RI,NEXT
		RETI
NEXT:	CPL P1.2
		RETI
		END