;T2COM: TF2 EXF2 RCLK TCLK EXEN2 TR2 C/T2 CP/RL2
;T2MOD:  T2OE DCEN
;IE: EA ET2 ES ET1 EX1 ET0 EX0
;IP: PT2 PS PT1 PX1 PT0 PX0
		T2CON EQU 0C8H
		TR2 EQU T2CON.2
		TF2 EQU T2CON.7
		ET2 EQU IE.5
		RCAP2L EQU 0CAH
		RCAP2H EQU 0CBH
		TH2 EQU 0CDH
		TL2 EQU 0CCH	
		ORG	0000H
		LJMP MAIN
		ORG	002BH
		LJMP IT2F
MAIN:	CLR	P1.0
		MOV R0,#20
		SETB EA
		SETB ET2
		MOV RCAP2H,#3CH
		MOV RCAP2L,#0ADH
		MOV TH2,#3CH
		MOV TL2,#0ADH
 		SETB TR2
HERE:	SJMP HERE
IT2F:	CLR TF2
		DJNZ R0,NEXT
		CPL P1.0
		MOV R0,#20
NEXT:	NOP
		NOP
		RETI
		END