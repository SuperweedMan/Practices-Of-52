		T2CON EQU 0C8H
		TR2 EQU T2CON.2
		TF2 EQU T2CON.7
		EXF2 EQU T2CON.6
		ET2 EQU IE.5
		RCAP2L EQU 0CAH
		RCAP2H EQU 0CBH
		TH2 EQU 0CDH
		TL2 EQU 0CCH	
		CP_RL2 EQU T2CON.0
		EXEN2 EQU T2CON.3

		ORG 0000H
		LJMP MAIN
		ORG 002BH
		LJMP IT2F
MAIN:	MOV R0,#7FH
		MOV R1,#2
		SETB ET2
		SETB EA
		SETB EXEN2
		SETB CP_RL2
		SETB TR2
HERE:	CJNE R1,#0,HERE
		CLR EA
		CLR ET2
		CLR C
		MOV A,7DH
		SUBB A,7FH
		MOV R5,A       ;低四位      
		MOV A,7CH
		SUBB A,7EH
		MOV R6,A       ;高四位
		MOV P0,R5
		MOV P1,R6
HERE2:	SJMP HERE2
IT2F:	JBC EXF2,NEXT
		CLR TF2
		RETI
NEXT:	CJNE R1,#0,NEXT2
		RETI
NEXT2:	MOV @R0,RCAP2L
		DEC R0
		MOV @R0,RCAP2H
		DEC R0
		DEC R1
		RETI
		END